# Keil uVision project RoboMasterC_WheelLeg.uvprojx, settings and files
target RoboMasterC_WheelLeg (6190000::V6.19::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000)
  output: RoboMasterC_WheelLeg +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F407xx,STM32F407IGHx,_USE_LEGACY_HAL
  c misc: --target=arm-arm-none-eabi -mcpu=cortex-m4 -mfpu=fpv4-sp-d16 -mfloat-abi=hard -std=c11
  c include: ..\include;..\board;..\..\config;..\third_party\balance\Drivers\CMSIS\Include;..\third_party\balance\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\third_party\balance\Drivers\STM32F4xx_HAL_Driver\Inc;..\third_party\balance\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\third_party\balance\FML\bmi088;..\third_party\balance\FML\ekf;RTE\_RoboMasterC_WheelLeg
  asm misc: --target=arm-arm-none-eabi -mcpu=cortex-m4 -mfpu=fpv4-sp-d16 -mfloat-abi=hard
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Board
    ../board/: startup_stm32f407xx.s system_stm32f4xx.c gpio.c can.c stm32f4xx_it.c spi.c dma.c tim.c usart.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c error_handler.c
  group STM32HAL
    ../third_party/balance/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_exti.c
  group Application
    ../src/: main.c system.c
  group Control
    ../src/: right_side_control.c lqr_controller.c lqr_gains.c vmc_math.c
  group Drivers
    ../src/: can_driver.c motor_controller.c
  group Config
    ../../config/: hardware_config.h motor_config.h bringup_config.h
